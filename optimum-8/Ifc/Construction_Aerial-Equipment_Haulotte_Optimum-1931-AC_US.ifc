Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2019-12-09T21:36:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Dec 09 21:36:53 2019 * Host: N08 * Database: C:\Users\N~1\AppData\Local\Temp\{D41FFD85-1813-4A3E-AE08-711B26DDB2AC}\ifc * Database version: 5507 * Database creation date: Mon Dec 09 21:36:49 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Dec 09 21:36:50 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Dec 09 21:36:50 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: Optimum 1931 AC, Construction_Aerial-Equipment_Haulotte_Optimum-1931-AC_US:Optimum 1931 AC:567290
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Metal - Haulotte - Black, Red, Metal - Haulotte - Grey, Metal - Haulotte - Yellow, Metal - Haulotte - Grey Dark, Metal - Haulotte - White
Type - Autre(Type) - Catégorie: Equipement spécialisé; Hydraulic System Capacity: 7 l (1,8 gal); Machine Weight: 1520 kg ( 2800 lbs); Nom de la famille: Construction_Aerial-Equipment_Haulotte_Optimum-1931-AC_US
Type - Données d'identification(Type) - Code d'assemblage: E10; Description: Unrivalled driving and lifting experience Asynchronous motorization Ultra-precise driving Fast and proportional movements Better turning radius Maximum versatility Passing through standard doors Automatic anti-tilt device (mobile potholes) Indoor and outdoor use Minimal maintenance and downtime Maintenance-free asynchronous motors Easy access 2 swivel bins Haulotte Activ'Screen (on-board diagnostics) Easy transport Long service life Extreme robustness Optimized total cost of ownership; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: Optimum 1931 AC; Nom du type: Optimum 1931 AC; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://www.bimobject.com/haulotte/product/optimum-8; Titre OmniClass: Other Utility and Transportation Construction Products; URL: http://www.haulotte-usa.com/
Type - Données(Type) - Batteries: 24 V - 225 Ah; Driveable at Full Height up to: 5,77 m (18 ft 11 in); Drive Speed: 0,5-4,5 km/h (0,3-2.8 mph); Gradeability: 25%; Ground Clearance: 8,7 cm (4 in); Ground Clearance - Pothole Guards Deployed: 2 cm (1 in); Height - Stowed: 1,98 m (6 ft 6 in); Length: 1,9 m (6 ft 3 in); Length Extension: 0,86 m (2 ft 10 in); Lift Capacity – Inside: 2 persons - 230 kg (2 persons - 500 lbs); Lift Capacity - Outside: 1 person - 230 kg (1 person - 500 lbs); Max Ground Pressure of Wheel on Paved Ground: 15,7 daN/cm²; Overall Width: 0,79 m (2 ft 7 in); Platform Height: 5,77 m (18 ft 11 in); Platform Length - Extended: 2,59 m (8 ft 6 in); Platform Length - Outside: 1,72 m (5 ft 8 in); Platform Width – Outside: 0,74 m (2 ft 5 in); Tilt: 1,5° - 3°; Tires: non-marking tires 12,5 x 4,13; Turning Radius - Inside: 1 m (3 ft 3 in); Turning Radius - Outside: 1,5 m (4 ft 11 in); Wheelbase: 1,38 m (4 ft 6 in); Working Height: 7,77 m (24 ft 11 in)
Type - Général(Type) - Edition number: 1
Pset_BuildingElementProxyCommon - Reference: Optimum 1931 AC
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_Optimum-1931-AC_US: Optimum 1931 AC; Famille et type: Construction_Aerial-Equipment_Haulotte_Optimum-1931-AC_US: Optimum 1931 AC; H CTRL: 5.255 m; ID du type: Construction_Aerial-Equipment_Haulotte_Optimum-1931-AC_US: Optimum 1931 AC; L: 0.7645 m; Type: Construction_Aerial-Equipment_Haulotte_Optimum-1931-AC_US: Optimum 1931 AC
Construction - Extension Desk Length: 0.8 m; Maximum Platform Height on Wheel: 5.77 m; Reach Diagram: no; Turning Radius: no; Working Area: no
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 34.371 m2; Volume: 3.45348 m3
Graphismes - Branding: yes
Phase de construction - Phase de création: Nouvelle construction

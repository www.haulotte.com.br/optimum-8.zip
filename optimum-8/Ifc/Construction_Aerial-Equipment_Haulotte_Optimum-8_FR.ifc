Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2019-12-09T21:35:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Dec 09 21:35:31 2019 * Host: N08 * Database: C:\Users\N~1\AppData\Local\Temp\{FA805C68-B44A-427F-985A-A7AF126C3DE8}\ifc * Database version: 5507 * Database creation date: Mon Dec 09 21:35:27 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Dec 09 21:35:28 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Dec 09 21:35:28 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: Optimum 8, Construction_Aerial-Equipment_Haulotte_Optimum-8_FR:Optimum 8:567290
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Metal - Haulotte - Black, Red, Metal - Haulotte - Grey, Metal - Haulotte - Yellow, Metal - Haulotte - Grey Dark, Metal - Haulotte - White
Type - Autre(Type) - Catégorie: Equipement spécialisé; Capacité Réservoir Huile Hydraulique: 7 l (1,8 gal); Masse Machine (CE): 1520 kg ( 2800 lbs); Nom de la famille: Construction_Aerial-Equipment_Haulotte_Optimum-8_FR
Type - Données d'identification(Type) - Code d'assemblage: E10; Description: Expérience de conduite et d'élévation incomparable Motorisation asynchrone Conduite ultra précise Mouvements rapides et proportionnels Meilleur rayon de braquage Polyvalence maximale Franchissement de portes standard Dispositif anti-basculement automatique (potholes mobiles) Utilisation intérieure et extérieure Maintenance et immobilisation minimales Moteurs asynchrones sans maintenance Accès facile 2 bacs pivotants Haulotte Activ'Screen (diagnostic embarqué) Transport facile Durée de vie prolongée Extrême robustesse Coût total de possession optimisé; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: Optimum 8; Nom du type: Optimum 8; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://www.bimobject.com/haulotte/product/optimum-8; Titre OmniClass: Other Utility and Transportation Construction Products; URL: http://www.haulotte.co.uk
Type - Données(Type) - Batteries: 24 V - 225 Ah; Capacité Maximum – Extérieur: 1 person - 230 kg (1 person - 500 lbs); Capacité Maximum - Intérieur: 2 persons - 230 kg (2 persons - 500 lbs); Devers: 1,5° - 3°; Empattement: 1,38 m (4 ft 6 in); Garde au Sol: 8,7 cm (4 in); Garde au Sol - Potholes Baissés: 2 cm (1 in); Hauteur Maximale de Translation: 5,77 m (18 ft 11 in); Hauteur Plateforme: 5,77 m (18 ft 11 in); Hauteur Repliée: 1,98 m (6 ft 6 in); Hauteur Travail: 7,77 m (24 ft 11 in); Largeur Hors Tout: 0,79 m (2 ft 7 in); Largeur Plateforme: 0,74 m (2 ft 5 in); Longueur Extension: 0,86 m (2 ft 10 in); Longueur Hors Tout: 1,9 m (6 ft 3 in); Longueur Plateforme: 1,72 m (5 ft 8 in); Longueur Plateforme Étendue: 2,59 m (8 ft 6 in); Pente Maximum: 25%; Pneus: non-marking tires 12,5 x 4,13; Pression Max au Sol: 15,7 daN/cm²; Rayon de Braquage Exterieur: 1,5 m (4 ft 11 in); Rayon de Braquage Interieur: 1 m (3 ft 3 in); Vitesse de Translation: 0,5-4,5 km/h (0,3-2.8 mph)
Type - Général(Type) - Edition number: 1
Pset_BuildingElementProxyCommon - Reference: Optimum 8
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_Optimum-8_FR: Optimum 8; Famille et type: Construction_Aerial-Equipment_Haulotte_Optimum-8_FR: Optimum 8; H CTRL: 5.255 m; ID du type: Construction_Aerial-Equipment_Haulotte_Optimum-8_FR: Optimum 8; L: 0.7645 m; Type: Construction_Aerial-Equipment_Haulotte_Optimum-8_FR: Optimum 8
Construction - Abaque de Travail: no; Extension Plateforme: 0.8 m; Hauteur Maxi du Plancher sur Roue: 5.77 m; Rayon de Braquage Exterieur: no; Zone de Travail: no
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 34.3609 m2; Volume: 3.45345 m3
Graphismes - Marque: yes
Phase de construction - Phase de création: Nouvelle construction
